Commit message: changing URDF dimensions

File: threeDOF.urdf (robot description, URDF)
Before this commit: robot threeDOF, 16 links, 15 joints
Links:
- link link3bar: geometry visual cylinder length=0.22 radius=0.02
